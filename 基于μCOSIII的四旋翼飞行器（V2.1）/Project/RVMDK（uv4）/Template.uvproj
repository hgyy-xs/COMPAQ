# Keil uVision project Template.uvproj, settings and files
target FLY_Control——F4 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\startup;..\..\Libraries\FWlib\inc;..\..\Libraries\CMSIS;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\User\LED;..\..\User;..\..\UCOSIII\uC-CPU;..\..\UCOSIII\uC-LIB;..\..\UCOSIII\uCOS-III;..\..\UCOSIII\UCOS_BSP;..\..\UCOSIII\uCOS_CONFIG;..\..\UCOSIII\uCOS-III\Source;..\..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\Timer;..\..\User\Control;..\..\User\Data_Transfer;..\..\User\TIM_Output;..\..\User\Flash_Eeprom;..\..\User\TIM_Input;..\..\User\RC;..\..\User\KEY;..\..\User\IMU;..\..\User\USART2;..\..\User\IWDG;..\..\User\My_CTRL;..\..\User\ANO_Height;..\..\User\My_Height_CTRL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c stm32f4xx_conf.h Para.h Para.c include.h
    ../../User/LED/: led.c
    ../../User/Timer/: Timer.c
    ../../User/Control/: Control.c
    ../../User/Data_Transfer/: Data_Transfer.c
    ../../User/TIM_Output/: Tim_Pwm_Out.c
    ../../User/Flash_Eeprom/: Flash_Eeprom.c
    ../../User/RC/: Rc.c
    ../../User/TIM_Input/: Tim_PPm_In.c
    ../../User/KEY/: key.c
    ../../User/IMU/: Imu.c
    ../../User/USART2/: USART2.c
    ../../User/IWDG/: IWDG.c
    ../../User/My_CTRL/: My_Ctrl.c
    ../../User/ANO_Height/: ultra_ctrl.c
    ../../User/My_Height_CTRL/: My_Height.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
  group UCOS-III_BSP
    ../../UCOSIII/UCOS_BSP/: bsp.c
  group UCOS-III_CPU
    ../../UCOSIII/uC-CPU/: cpu_core.c
    ../../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOS-III_LIB
    ../../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOS-III_CORE
    ../../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS-III_PORT
    ../../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS-III_CONFIG
    ../../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group DOC
    ../../Doc/: readme.txt
